FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

PR = "r1"
